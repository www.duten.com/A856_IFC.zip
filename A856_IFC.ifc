Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-08-19T17:49:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 19 17:49:22 2021 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{05B32DE1-B644-435F-89B1-230E20733798}\ifc * Database version: 5507 * Database creation date: Thu Aug 19 17:49:19 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 19 17:49:20 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 19 17:49:20 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: Brushed Stainless Steel Click Clack Waste with Overflow, Duten_WstsForWshBsns_A856:Brushed Stainless Steel Click Clack Waste with Overflow:314038
In: Level 0
Type - ElementType: Brushed Stainless Steel Click Clack Waste with Overflow; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_BrushedStainlessSteel, Duten_Plastic_White
Pset_ManufacturerTypeInformation - ModelReference: Brushed Stainless Steel Click Clack Waste with Overflow; Manufacturer: Duten

# IfcFurnishingElement: Matte Black Click Clack Waste with Overflow, Duten_WstsForWshBsns_A856:Matte Black Click Clack Waste with Overflow:314044
In: Level 0
Type - ElementType: Matte Black Click Clack Waste with Overflow; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_MatteBlack, Duten_Plastic_White
Pset_ManufacturerTypeInformation - ModelReference: Matte Black Click Clack Waste with Overflow; Manufacturer: Duten

# IfcFurnishingElement: Polished Stainless Steel Click Clack Waste with Overflow, Duten_WstsForWshBsns_A856:Polished Stainless Steel Click Clack Waste with Overflow:314041
In: Level 0
Type - ElementType: Polished Stainless Steel Click Clack Waste with Overflow; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_Polished, Duten_Plastic_White
Pset_ManufacturerTypeInformation - ModelReference: Polished Stainless Steel Click Clack Waste with Overflow; Manufacturer: Duten
